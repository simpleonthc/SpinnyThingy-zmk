## config/boards/shields/spinnythingy/Kconfig.deconfig
```kconfig
if SHIELD_SPINNYTHINGY

config ZMK_KEYBOARD_NAME
    default "SpinnyThingy"

endif
```
